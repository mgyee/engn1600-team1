v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 60 -60 0 0 {name=p1 lab=JMP}
C {lab_wire.sym} 230 -410 0 0 {name=p2 sig_type=std_logic lab=xxx}
C {ipin.sym} 60 -110 0 0 {name=p3 lab=BR}
C {iopin.sym} 20 -170 0 0 {name=p4 lab=VDD}
C {iopin.sym} 20 -220 0 0 {name=p5 lab=VSS}
C {ipin.sym} 60 -20 0 0 {name=p6 lab=DISP[7..0]}
