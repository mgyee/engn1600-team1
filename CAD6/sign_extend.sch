v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 150 -300 300 -300 {lab=IN0}
N 150 -280 300 -280 {lab=IN1}
N 150 -260 300 -260 {lab=IN2}
N 150 -240 300 -240 {lab=IN3}
N 150 -220 300 -220 {lab=IN4}
N 150 -200 300 -200 {lab=IN5}
N 150 -180 300 -180 {lab=IN6}
N 150 -160 300 -160 {lab=IN7}
N 200 -120 350 -120 {lab=IN7}
N 200 -100 350 -100 {lab=IN7}
N 200 -80 350 -80 {lab=IN7}
N 200 -60 350 -60 {lab=IN7}
N 200 -40 350 -40 {lab=IN7}
N 200 -20 350 -20 {lab=IN7}
N 200 0 350 0 {lab=IN7}
N 200 20 350 20 {lab=IN7}
C {ipin.sym} 100 -200 0 0 {name=p1 lab=IN[7..0]}
C {opin.sym} 500 -200 0 0 {name=p2 lab=OUT[15..0]}
C {lab_wire.sym} 150 -300 0 0 {lab=IN0}
C {lab_wire.sym} 300 -300 0 0 {lab=OUT0}
C {lab_wire.sym} 150 -280 0 0 {lab=IN1}
C {lab_wire.sym} 300 -280 0 0 {lab=OUT1}
C {lab_wire.sym} 150 -260 0 0 {lab=IN2}
C {lab_wire.sym} 300 -260 0 0 {lab=OUT2}
C {lab_wire.sym} 150 -240 0 0 {lab=IN3}
C {lab_wire.sym} 300 -240 0 0 {lab=OUT3}
C {lab_wire.sym} 150 -220 0 0 {lab=IN4}
C {lab_wire.sym} 300 -220 0 0 {lab=OUT4}
C {lab_wire.sym} 150 -200 0 0 {lab=IN5}
C {lab_wire.sym} 300 -200 0 0 {lab=OUT5}
C {lab_wire.sym} 150 -180 0 0 {lab=IN6}
C {lab_wire.sym} 300 -180 0 0 {lab=OUT6}
C {lab_wire.sym} 150 -160 0 0 {lab=IN7}
C {lab_wire.sym} 300 -160 0 0 {lab=OUT7}
C {lab_wire.sym} 200 -120 0 0 {lab=IN7}
C {lab_wire.sym} 350 -120 0 0 {lab=OUT8}
C {lab_wire.sym} 200 -100 0 0 {lab=IN7}
C {lab_wire.sym} 350 -100 0 0 {lab=OUT9}
C {lab_wire.sym} 200 -80 0 0 {lab=IN7}
C {lab_wire.sym} 350 -80 0 0 {lab=OUT10}
C {lab_wire.sym} 200 -60 0 0 {lab=IN7}
C {lab_wire.sym} 350 -60 0 0 {lab=OUT11}
C {lab_wire.sym} 200 -40 0 0 {lab=IN7}
C {lab_wire.sym} 350 -40 0 0 {lab=OUT12}
C {lab_wire.sym} 200 -20 0 0 {lab=IN7}
C {lab_wire.sym} 350 -20 0 0 {lab=OUT13}
C {lab_wire.sym} 200 0 0 0 {lab=IN7}
C {lab_wire.sym} 350 0 0 0 {lab=OUT14}
C {lab_wire.sym} 200 20 0 0 {lab=IN7}
C {lab_wire.sym} 350 20 0 0 {lab=OUT15}
