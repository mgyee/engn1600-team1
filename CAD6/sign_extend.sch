v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} -110 0 0 0 {name=p1 lab=IN}
C {opin.sym} 110 0 0 0 {name=p2 lab=OUT}
C {engn1600-team1/CAD6/inv.sym} -90 0 0 0 {name=x1 kINV=3}
C {engn1600-team1/CAD6/inv.sym} 20 0 0 0 {name=x2 kINV=9}
C {iopin.sym} -190 -10 2 0 {name=p3 lab=VDD}
C {iopin.sym} -190 10 2 0 {name=p4 lab=VSS}
C {lab_pin.sym} -70 -40 0 1 {name=p5 lab=VDD}
C {lab_pin.sym} -70 40 0 1 {name=p6 lab=VSS}
C {lab_pin.sym} 40 -40 0 1 {name=p7 lab=VDD}
C {lab_pin.sym} 40 40 0 1 {name=p8 lab=VSS}
