v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 -1000 -1000 1000 -600 {flags=graph
y1=0
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0n
x2=150n
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
digital=1
autoload=1
color="4 5 6"
node="CLK;clk
PC[15..0];pc15,pc14,pc13,pc12,pc11,pc10,pc9,pc8,pc7,pc6,pc5,pc4,pc3,pc2,pc1,pc0
IQ[15..0];imem_q15,imem_q14,imem_q13,imem_q12,imem_q11,imem_q10,imem_q9,imem_q8,imem_q7,imem_q6,imem_q5,imem_q4,imem_q3,imem_q2,imem_q1,imem_q0
"
rawfile=/foss/designs/engn1600-team1/CAD7/imem_tb.raw}
