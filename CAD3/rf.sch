** sch_path: CAD3/rf.sch
**.subckt rf RA0 RB0 WE0 RA1 RB1 WE1 RA2 RB2 WE2 RA3 RB3 WE3 RA4 RB4 WE4 RA5 RB5 WE5 RA6 RB6 WE6 RA7
*+ RB7 WE7 RA8 RB8 WE8 RA9 RB9 WE9 RA10 RB10 WE10 RA11 RB11 WE11 RA12 RB12 WE12 RA13 RB13 WE13 RA14 RB14
*+ WE14 RA15 RB15 WE15 CLK WEM D0 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 QB0 QB1 QB2 QB3 QB4
*+ QB5 QB6 QB7 QB8 QB9 QB10 QB11 QB12 QB13 QB14 QB15 QA0 QA1 QA2 QA3 QA4 QA5 QA6 QA7 QA8 QA9 QA10 QA11
*+ QA12 QA13 QA14 QA15
*.ipin RA0
*.ipin RB0
*.ipin WE0
*.ipin RA1
*.ipin RB1
*.ipin WE1
*.ipin RA2
*.ipin RB2
*.ipin WE2
*.ipin RA3
*.ipin RB3
*.ipin WE3
*.ipin RA4
*.ipin RB4
*.ipin WE4
*.ipin RA5
*.ipin RB5
*.ipin WE5
*.ipin RA6
*.ipin RB6
*.ipin WE6
*.ipin RA7
*.ipin RB7
*.ipin WE7
*.ipin RA8
*.ipin RB8
*.ipin WE8
*.ipin RA9
*.ipin RB9
*.ipin WE9
*.ipin RA10
*.ipin RB10
*.ipin WE10
*.ipin RA11
*.ipin RB11
*.ipin WE11
*.ipin RA12
*.ipin RB12
*.ipin WE12
*.ipin RA13
*.ipin RB13
*.ipin WE13
*.ipin RA14
*.ipin RB14
*.ipin WE14
*.ipin RA15
*.ipin RB15
*.ipin WE15
*.ipin CLK
*.ipin WEM
*.ipin D0
*.ipin D1
*.ipin D2
*.ipin D3
*.ipin D4
*.ipin D5
*.ipin D6
*.ipin D7
*.ipin D8
*.ipin D9
*.ipin D10
*.ipin D11
*.ipin D12
*.ipin D13
*.ipin D14
*.ipin D15
*.opin QB0
*.opin QB1
*.opin QB2
*.opin QB3
*.opin QB4
*.opin QB5
*.opin QB6
*.opin QB7
*.opin QB8
*.opin QB9
*.opin QB10
*.opin QB11
*.opin QB12
*.opin QB13
*.opin QB14
*.opin QB15
*.opin QA0
*.opin QA1
*.opin QA2
*.opin QA3
*.opin QA4
*.opin QA5
*.opin QA6
*.opin QA7
*.opin QA8
*.opin QA9
*.opin QA10
*.opin QA11
*.opin QA12
*.opin QA13
*.opin QA14
*.opin QA15
x0_0 VDD VSS QA0b WE0CLK WE0CLKb RA0 RB0 QB0b N0 slave_latch kQ=1
x0_1 VDD VSS QA1b WE0CLK WE0CLKb RA0 RB0 QB1b N1 slave_latch kQ=1
x0_2 VDD VSS QA2b WE0CLK WE0CLKb RA0 RB0 QB2b N2 slave_latch kQ=1
x0_3 VDD VSS QA3b WE0CLK WE0CLKb RA0 RB0 QB3b N3 slave_latch kQ=1
x0_4 VDD VSS QA4b WE0CLK WE0CLKb RA0 RB0 QB4b N4 slave_latch kQ=1
x0_5 VDD VSS QA5b WE0CLK WE0CLKb RA0 RB0 QB5b N5 slave_latch kQ=1
x0_6 VDD VSS QA6b WE0CLK WE0CLKb RA0 RB0 QB6b N6 slave_latch kQ=1
x0_7 VDD VSS QA7b WE0CLK WE0CLKb RA0 RB0 QB7b N7 slave_latch kQ=1
x0_8 VDD VSS QA8b WE0CLK WE0CLKb RA0 RB0 QB8b N8 slave_latch kQ=1
x0_9 VDD VSS QA9b WE0CLK WE0CLKb RA0 RB0 QB9b N9 slave_latch kQ=1
x0_10 VDD VSS QA10b WE0CLK WE0CLKb RA0 RB0 QB10b N10 slave_latch kQ=1
x0_11 VDD VSS QA11b WE0CLK WE0CLKb RA0 RB0 QB11b N11 slave_latch kQ=1
x0_12 VDD VSS QA12b WE0CLK WE0CLKb RA0 RB0 QB12b N12 slave_latch kQ=1
x0_13 VDD VSS QA13b WE0CLK WE0CLKb RA0 RB0 QB13b N13 slave_latch kQ=1
x0_14 VDD VSS QA14b WE0CLK WE0CLKb RA0 RB0 QB14b N14 slave_latch kQ=1
x0_15 VDD VSS QA15b WE0CLK WE0CLKb RA0 RB0 QB15b N15 slave_latch kQ=1
x1_0 VDD VSS QA0b WE1CLK WE1CLKb RA1 RB1 QB0b N0 slave_latch kQ=1
x1_1 VDD VSS QA1b WE1CLK WE1CLKb RA1 RB1 QB1b N1 slave_latch kQ=1
x1_2 VDD VSS QA2b WE1CLK WE1CLKb RA1 RB1 QB2b N2 slave_latch kQ=1
x1_3 VDD VSS QA3b WE1CLK WE1CLKb RA1 RB1 QB3b N3 slave_latch kQ=1
x1_4 VDD VSS QA4b WE1CLK WE1CLKb RA1 RB1 QB4b N4 slave_latch kQ=1
x1_5 VDD VSS QA5b WE1CLK WE1CLKb RA1 RB1 QB5b N5 slave_latch kQ=1
x1_6 VDD VSS QA6b WE1CLK WE1CLKb RA1 RB1 QB6b N6 slave_latch kQ=1
x1_7 VDD VSS QA7b WE1CLK WE1CLKb RA1 RB1 QB7b N7 slave_latch kQ=1
x1_8 VDD VSS QA8b WE1CLK WE1CLKb RA1 RB1 QB8b N8 slave_latch kQ=1
x1_9 VDD VSS QA9b WE1CLK WE1CLKb RA1 RB1 QB9b N9 slave_latch kQ=1
x1_10 VDD VSS QA10b WE1CLK WE1CLKb RA1 RB1 QB10b N10 slave_latch kQ=1
x1_11 VDD VSS QA11b WE1CLK WE1CLKb RA1 RB1 QB11b N11 slave_latch kQ=1
x1_12 VDD VSS QA12b WE1CLK WE1CLKb RA1 RB1 QB12b N12 slave_latch kQ=1
x1_13 VDD VSS QA13b WE1CLK WE1CLKb RA1 RB1 QB13b N13 slave_latch kQ=1
x1_14 VDD VSS QA14b WE1CLK WE1CLKb RA1 RB1 QB14b N14 slave_latch kQ=1
x1_15 VDD VSS QA15b WE1CLK WE1CLKb RA1 RB1 QB15b N15 slave_latch kQ=1
x2_0 VDD VSS QA0b WE2CLK WE2CLKb RA2 RB2 QB0b N0 slave_latch kQ=1
x2_1 VDD VSS QA1b WE2CLK WE2CLKb RA2 RB2 QB1b N1 slave_latch kQ=1
x2_2 VDD VSS QA2b WE2CLK WE2CLKb RA2 RB2 QB2b N2 slave_latch kQ=1
x2_3 VDD VSS QA3b WE2CLK WE2CLKb RA2 RB2 QB3b N3 slave_latch kQ=1
x2_4 VDD VSS QA4b WE2CLK WE2CLKb RA2 RB2 QB4b N4 slave_latch kQ=1
x2_5 VDD VSS QA5b WE2CLK WE2CLKb RA2 RB2 QB5b N5 slave_latch kQ=1
x2_6 VDD VSS QA6b WE2CLK WE2CLKb RA2 RB2 QB6b N6 slave_latch kQ=1
x2_7 VDD VSS QA7b WE2CLK WE2CLKb RA2 RB2 QB7b N7 slave_latch kQ=1
x2_8 VDD VSS QA8b WE2CLK WE2CLKb RA2 RB2 QB8b N8 slave_latch kQ=1
x2_9 VDD VSS QA9b WE2CLK WE2CLKb RA2 RB2 QB9b N9 slave_latch kQ=1
x2_10 VDD VSS QA10b WE2CLK WE2CLKb RA2 RB2 QB10b N10 slave_latch kQ=1
x2_11 VDD VSS QA11b WE2CLK WE2CLKb RA2 RB2 QB11b N11 slave_latch kQ=1
x2_12 VDD VSS QA12b WE2CLK WE2CLKb RA2 RB2 QB12b N12 slave_latch kQ=1
x2_13 VDD VSS QA13b WE2CLK WE2CLKb RA2 RB2 QB13b N13 slave_latch kQ=1
x2_14 VDD VSS QA14b WE2CLK WE2CLKb RA2 RB2 QB14b N14 slave_latch kQ=1
x2_15 VDD VSS QA15b WE2CLK WE2CLKb RA2 RB2 QB15b N15 slave_latch kQ=1
x3_0 VDD VSS QA0b WE3CLK WE3CLKb RA3 RB3 QB0b N0 slave_latch kQ=1
x3_1 VDD VSS QA1b WE3CLK WE3CLKb RA3 RB3 QB1b N1 slave_latch kQ=1
x3_2 VDD VSS QA2b WE3CLK WE3CLKb RA3 RB3 QB2b N2 slave_latch kQ=1
x3_3 VDD VSS QA3b WE3CLK WE3CLKb RA3 RB3 QB3b N3 slave_latch kQ=1
x3_4 VDD VSS QA4b WE3CLK WE3CLKb RA3 RB3 QB4b N4 slave_latch kQ=1
x3_5 VDD VSS QA5b WE3CLK WE3CLKb RA3 RB3 QB5b N5 slave_latch kQ=1
x3_6 VDD VSS QA6b WE3CLK WE3CLKb RA3 RB3 QB6b N6 slave_latch kQ=1
x3_7 VDD VSS QA7b WE3CLK WE3CLKb RA3 RB3 QB7b N7 slave_latch kQ=1
x3_8 VDD VSS QA8b WE3CLK WE3CLKb RA3 RB3 QB8b N8 slave_latch kQ=1
x3_9 VDD VSS QA9b WE3CLK WE3CLKb RA3 RB3 QB9b N9 slave_latch kQ=1
x3_10 VDD VSS QA10b WE3CLK WE3CLKb RA3 RB3 QB10b N10 slave_latch kQ=1
x3_11 VDD VSS QA11b WE3CLK WE3CLKb RA3 RB3 QB11b N11 slave_latch kQ=1
x3_12 VDD VSS QA12b WE3CLK WE3CLKb RA3 RB3 QB12b N12 slave_latch kQ=1
x3_13 VDD VSS QA13b WE3CLK WE3CLKb RA3 RB3 QB13b N13 slave_latch kQ=1
x3_14 VDD VSS QA14b WE3CLK WE3CLKb RA3 RB3 QB14b N14 slave_latch kQ=1
x3_15 VDD VSS QA15b WE3CLK WE3CLKb RA3 RB3 QB15b N15 slave_latch kQ=1
x4_0 VDD VSS QA0b WE4CLK WE4CLKb RA4 RB4 QB0b N0 slave_latch kQ=1
x4_1 VDD VSS QA1b WE4CLK WE4CLKb RA4 RB4 QB1b N1 slave_latch kQ=1
x4_2 VDD VSS QA2b WE4CLK WE4CLKb RA4 RB4 QB2b N2 slave_latch kQ=1
x4_3 VDD VSS QA3b WE4CLK WE4CLKb RA4 RB4 QB3b N3 slave_latch kQ=1
x4_4 VDD VSS QA4b WE4CLK WE4CLKb RA4 RB4 QB4b N4 slave_latch kQ=1
x4_5 VDD VSS QA5b WE4CLK WE4CLKb RA4 RB4 QB5b N5 slave_latch kQ=1
x4_6 VDD VSS QA6b WE4CLK WE4CLKb RA4 RB4 QB6b N6 slave_latch kQ=1
x4_7 VDD VSS QA7b WE4CLK WE4CLKb RA4 RB4 QB7b N7 slave_latch kQ=1
x4_8 VDD VSS QA8b WE4CLK WE4CLKb RA4 RB4 QB8b N8 slave_latch kQ=1
x4_9 VDD VSS QA9b WE4CLK WE4CLKb RA4 RB4 QB9b N9 slave_latch kQ=1
x4_10 VDD VSS QA10b WE4CLK WE4CLKb RA4 RB4 QB10b N10 slave_latch kQ=1
x4_11 VDD VSS QA11b WE4CLK WE4CLKb RA4 RB4 QB11b N11 slave_latch kQ=1
x4_12 VDD VSS QA12b WE4CLK WE4CLKb RA4 RB4 QB12b N12 slave_latch kQ=1
x4_13 VDD VSS QA13b WE4CLK WE4CLKb RA4 RB4 QB13b N13 slave_latch kQ=1
x4_14 VDD VSS QA14b WE4CLK WE4CLKb RA4 RB4 QB14b N14 slave_latch kQ=1
x4_15 VDD VSS QA15b WE4CLK WE4CLKb RA4 RB4 QB15b N15 slave_latch kQ=1
x5_0 VDD VSS QA0b WE5CLK WE5CLKb RA5 RB5 QB0b N0 slave_latch kQ=1
x5_1 VDD VSS QA1b WE5CLK WE5CLKb RA5 RB5 QB1b N1 slave_latch kQ=1
x5_2 VDD VSS QA2b WE5CLK WE5CLKb RA5 RB5 QB2b N2 slave_latch kQ=1
x5_3 VDD VSS QA3b WE5CLK WE5CLKb RA5 RB5 QB3b N3 slave_latch kQ=1
x5_4 VDD VSS QA4b WE5CLK WE5CLKb RA5 RB5 QB4b N4 slave_latch kQ=1
x5_5 VDD VSS QA5b WE5CLK WE5CLKb RA5 RB5 QB5b N5 slave_latch kQ=1
x5_6 VDD VSS QA6b WE5CLK WE5CLKb RA5 RB5 QB6b N6 slave_latch kQ=1
x5_7 VDD VSS QA7b WE5CLK WE5CLKb RA5 RB5 QB7b N7 slave_latch kQ=1
x5_8 VDD VSS QA8b WE5CLK WE5CLKb RA5 RB5 QB8b N8 slave_latch kQ=1
x5_9 VDD VSS QA9b WE5CLK WE5CLKb RA5 RB5 QB9b N9 slave_latch kQ=1
x5_10 VDD VSS QA10b WE5CLK WE5CLKb RA5 RB5 QB10b N10 slave_latch kQ=1
x5_11 VDD VSS QA11b WE5CLK WE5CLKb RA5 RB5 QB11b N11 slave_latch kQ=1
x5_12 VDD VSS QA12b WE5CLK WE5CLKb RA5 RB5 QB12b N12 slave_latch kQ=1
x5_13 VDD VSS QA13b WE5CLK WE5CLKb RA5 RB5 QB13b N13 slave_latch kQ=1
x5_14 VDD VSS QA14b WE5CLK WE5CLKb RA5 RB5 QB14b N14 slave_latch kQ=1
x5_15 VDD VSS QA15b WE5CLK WE5CLKb RA5 RB5 QB15b N15 slave_latch kQ=1
x6_0 VDD VSS QA0b WE6CLK WE6CLKb RA6 RB6 QB0b N0 slave_latch kQ=1
x6_1 VDD VSS QA1b WE6CLK WE6CLKb RA6 RB6 QB1b N1 slave_latch kQ=1
x6_2 VDD VSS QA2b WE6CLK WE6CLKb RA6 RB6 QB2b N2 slave_latch kQ=1
x6_3 VDD VSS QA3b WE6CLK WE6CLKb RA6 RB6 QB3b N3 slave_latch kQ=1
x6_4 VDD VSS QA4b WE6CLK WE6CLKb RA6 RB6 QB4b N4 slave_latch kQ=1
x6_5 VDD VSS QA5b WE6CLK WE6CLKb RA6 RB6 QB5b N5 slave_latch kQ=1
x6_6 VDD VSS QA6b WE6CLK WE6CLKb RA6 RB6 QB6b N6 slave_latch kQ=1
x6_7 VDD VSS QA7b WE6CLK WE6CLKb RA6 RB6 QB7b N7 slave_latch kQ=1
x6_8 VDD VSS QA8b WE6CLK WE6CLKb RA6 RB6 QB8b N8 slave_latch kQ=1
x6_9 VDD VSS QA9b WE6CLK WE6CLKb RA6 RB6 QB9b N9 slave_latch kQ=1
x6_10 VDD VSS QA10b WE6CLK WE6CLKb RA6 RB6 QB10b N10 slave_latch kQ=1
x6_11 VDD VSS QA11b WE6CLK WE6CLKb RA6 RB6 QB11b N11 slave_latch kQ=1
x6_12 VDD VSS QA12b WE6CLK WE6CLKb RA6 RB6 QB12b N12 slave_latch kQ=1
x6_13 VDD VSS QA13b WE6CLK WE6CLKb RA6 RB6 QB13b N13 slave_latch kQ=1
x6_14 VDD VSS QA14b WE6CLK WE6CLKb RA6 RB6 QB14b N14 slave_latch kQ=1
x6_15 VDD VSS QA15b WE6CLK WE6CLKb RA6 RB6 QB15b N15 slave_latch kQ=1
x7_0 VDD VSS QA0b WE7CLK WE7CLKb RA7 RB7 QB0b N0 slave_latch kQ=1
x7_1 VDD VSS QA1b WE7CLK WE7CLKb RA7 RB7 QB1b N1 slave_latch kQ=1
x7_2 VDD VSS QA2b WE7CLK WE7CLKb RA7 RB7 QB2b N2 slave_latch kQ=1
x7_3 VDD VSS QA3b WE7CLK WE7CLKb RA7 RB7 QB3b N3 slave_latch kQ=1
x7_4 VDD VSS QA4b WE7CLK WE7CLKb RA7 RB7 QB4b N4 slave_latch kQ=1
x7_5 VDD VSS QA5b WE7CLK WE7CLKb RA7 RB7 QB5b N5 slave_latch kQ=1
x7_6 VDD VSS QA6b WE7CLK WE7CLKb RA7 RB7 QB6b N6 slave_latch kQ=1
x7_7 VDD VSS QA7b WE7CLK WE7CLKb RA7 RB7 QB7b N7 slave_latch kQ=1
x7_8 VDD VSS QA8b WE7CLK WE7CLKb RA7 RB7 QB8b N8 slave_latch kQ=1
x7_9 VDD VSS QA9b WE7CLK WE7CLKb RA7 RB7 QB9b N9 slave_latch kQ=1
x7_10 VDD VSS QA10b WE7CLK WE7CLKb RA7 RB7 QB10b N10 slave_latch kQ=1
x7_11 VDD VSS QA11b WE7CLK WE7CLKb RA7 RB7 QB11b N11 slave_latch kQ=1
x7_12 VDD VSS QA12b WE7CLK WE7CLKb RA7 RB7 QB12b N12 slave_latch kQ=1
x7_13 VDD VSS QA13b WE7CLK WE7CLKb RA7 RB7 QB13b N13 slave_latch kQ=1
x7_14 VDD VSS QA14b WE7CLK WE7CLKb RA7 RB7 QB14b N14 slave_latch kQ=1
x7_15 VDD VSS QA15b WE7CLK WE7CLKb RA7 RB7 QB15b N15 slave_latch kQ=1
x8_0 VDD VSS QA0b WE8CLK WE8CLKb RA8 RB8 QB0b N0 slave_latch kQ=1
x8_1 VDD VSS QA1b WE8CLK WE8CLKb RA8 RB8 QB1b N1 slave_latch kQ=1
x8_2 VDD VSS QA2b WE8CLK WE8CLKb RA8 RB8 QB2b N2 slave_latch kQ=1
x8_3 VDD VSS QA3b WE8CLK WE8CLKb RA8 RB8 QB3b N3 slave_latch kQ=1
x8_4 VDD VSS QA4b WE8CLK WE8CLKb RA8 RB8 QB4b N4 slave_latch kQ=1
x8_5 VDD VSS QA5b WE8CLK WE8CLKb RA8 RB8 QB5b N5 slave_latch kQ=1
x8_6 VDD VSS QA6b WE8CLK WE8CLKb RA8 RB8 QB6b N6 slave_latch kQ=1
x8_7 VDD VSS QA7b WE8CLK WE8CLKb RA8 RB8 QB7b N7 slave_latch kQ=1
x8_8 VDD VSS QA8b WE8CLK WE8CLKb RA8 RB8 QB8b N8 slave_latch kQ=1
x8_9 VDD VSS QA9b WE8CLK WE8CLKb RA8 RB8 QB9b N9 slave_latch kQ=1
x8_10 VDD VSS QA10b WE8CLK WE8CLKb RA8 RB8 QB10b N10 slave_latch kQ=1
x8_11 VDD VSS QA11b WE8CLK WE8CLKb RA8 RB8 QB11b N11 slave_latch kQ=1
x8_12 VDD VSS QA12b WE8CLK WE8CLKb RA8 RB8 QB12b N12 slave_latch kQ=1
x8_13 VDD VSS QA13b WE8CLK WE8CLKb RA8 RB8 QB13b N13 slave_latch kQ=1
x8_14 VDD VSS QA14b WE8CLK WE8CLKb RA8 RB8 QB14b N14 slave_latch kQ=1
x8_15 VDD VSS QA15b WE8CLK WE8CLKb RA8 RB8 QB15b N15 slave_latch kQ=1
x9_0 VDD VSS QA0b WE9CLK WE9CLKb RA9 RB9 QB0b N0 slave_latch kQ=1
x9_1 VDD VSS QA1b WE9CLK WE9CLKb RA9 RB9 QB1b N1 slave_latch kQ=1
x9_2 VDD VSS QA2b WE9CLK WE9CLKb RA9 RB9 QB2b N2 slave_latch kQ=1
x9_3 VDD VSS QA3b WE9CLK WE9CLKb RA9 RB9 QB3b N3 slave_latch kQ=1
x9_4 VDD VSS QA4b WE9CLK WE9CLKb RA9 RB9 QB4b N4 slave_latch kQ=1
x9_5 VDD VSS QA5b WE9CLK WE9CLKb RA9 RB9 QB5b N5 slave_latch kQ=1
x9_6 VDD VSS QA6b WE9CLK WE9CLKb RA9 RB9 QB6b N6 slave_latch kQ=1
x9_7 VDD VSS QA7b WE9CLK WE9CLKb RA9 RB9 QB7b N7 slave_latch kQ=1
x9_8 VDD VSS QA8b WE9CLK WE9CLKb RA9 RB9 QB8b N8 slave_latch kQ=1
x9_9 VDD VSS QA9b WE9CLK WE9CLKb RA9 RB9 QB9b N9 slave_latch kQ=1
x9_10 VDD VSS QA10b WE9CLK WE9CLKb RA9 RB9 QB10b N10 slave_latch kQ=1
x9_11 VDD VSS QA11b WE9CLK WE9CLKb RA9 RB9 QB11b N11 slave_latch kQ=1
x9_12 VDD VSS QA12b WE9CLK WE9CLKb RA9 RB9 QB12b N12 slave_latch kQ=1
x9_13 VDD VSS QA13b WE9CLK WE9CLKb RA9 RB9 QB13b N13 slave_latch kQ=1
x9_14 VDD VSS QA14b WE9CLK WE9CLKb RA9 RB9 QB14b N14 slave_latch kQ=1
x9_15 VDD VSS QA15b WE9CLK WE9CLKb RA9 RB9 QB15b N15 slave_latch kQ=1
x10_0 VDD VSS QA0b WE10CLK WE10CLKb RA10 RB10 QB0b N0 slave_latch kQ=1
x10_1 VDD VSS QA1b WE10CLK WE10CLKb RA10 RB10 QB1b N1 slave_latch kQ=1
x10_2 VDD VSS QA2b WE10CLK WE10CLKb RA10 RB10 QB2b N2 slave_latch kQ=1
x10_3 VDD VSS QA3b WE10CLK WE10CLKb RA10 RB10 QB3b N3 slave_latch kQ=1
x10_4 VDD VSS QA4b WE10CLK WE10CLKb RA10 RB10 QB4b N4 slave_latch kQ=1
x10_5 VDD VSS QA5b WE10CLK WE10CLKb RA10 RB10 QB5b N5 slave_latch kQ=1
x10_6 VDD VSS QA6b WE10CLK WE10CLKb RA10 RB10 QB6b N6 slave_latch kQ=1
x10_7 VDD VSS QA7b WE10CLK WE10CLKb RA10 RB10 QB7b N7 slave_latch kQ=1
x10_8 VDD VSS QA8b WE10CLK WE10CLKb RA10 RB10 QB8b N8 slave_latch kQ=1
x10_9 VDD VSS QA9b WE10CLK WE10CLKb RA10 RB10 QB9b N9 slave_latch kQ=1
x10_10 VDD VSS QA10b WE10CLK WE10CLKb RA10 RB10 QB10b N10 slave_latch kQ=1
x10_11 VDD VSS QA11b WE10CLK WE10CLKb RA10 RB10 QB11b N11 slave_latch kQ=1
x10_12 VDD VSS QA12b WE10CLK WE10CLKb RA10 RB10 QB12b N12 slave_latch kQ=1
x10_13 VDD VSS QA13b WE10CLK WE10CLKb RA10 RB10 QB13b N13 slave_latch kQ=1
x10_14 VDD VSS QA14b WE10CLK WE10CLKb RA10 RB10 QB14b N14 slave_latch kQ=1
x10_15 VDD VSS QA15b WE10CLK WE10CLKb RA10 RB10 QB15b N15 slave_latch kQ=1
x11_0 VDD VSS QA0b WE11CLK WE11CLKb RA11 RB11 QB0b N0 slave_latch kQ=1
x11_1 VDD VSS QA1b WE11CLK WE11CLKb RA11 RB11 QB1b N1 slave_latch kQ=1
x11_2 VDD VSS QA2b WE11CLK WE11CLKb RA11 RB11 QB2b N2 slave_latch kQ=1
x11_3 VDD VSS QA3b WE11CLK WE11CLKb RA11 RB11 QB3b N3 slave_latch kQ=1
x11_4 VDD VSS QA4b WE11CLK WE11CLKb RA11 RB11 QB4b N4 slave_latch kQ=1
x11_5 VDD VSS QA5b WE11CLK WE11CLKb RA11 RB11 QB5b N5 slave_latch kQ=1
x11_6 VDD VSS QA6b WE11CLK WE11CLKb RA11 RB11 QB6b N6 slave_latch kQ=1
x11_7 VDD VSS QA7b WE11CLK WE11CLKb RA11 RB11 QB7b N7 slave_latch kQ=1
x11_8 VDD VSS QA8b WE11CLK WE11CLKb RA11 RB11 QB8b N8 slave_latch kQ=1
x11_9 VDD VSS QA9b WE11CLK WE11CLKb RA11 RB11 QB9b N9 slave_latch kQ=1
x11_10 VDD VSS QA10b WE11CLK WE11CLKb RA11 RB11 QB10b N10 slave_latch kQ=1
x11_11 VDD VSS QA11b WE11CLK WE11CLKb RA11 RB11 QB11b N11 slave_latch kQ=1
x11_12 VDD VSS QA12b WE11CLK WE11CLKb RA11 RB11 QB12b N12 slave_latch kQ=1
x11_13 VDD VSS QA13b WE11CLK WE11CLKb RA11 RB11 QB13b N13 slave_latch kQ=1
x11_14 VDD VSS QA14b WE11CLK WE11CLKb RA11 RB11 QB14b N14 slave_latch kQ=1
x11_15 VDD VSS QA15b WE11CLK WE11CLKb RA11 RB11 QB15b N15 slave_latch kQ=1
x12_0 VDD VSS QA0b WE12CLK WE12CLKb RA12 RB12 QB0b N0 slave_latch kQ=1
x12_1 VDD VSS QA1b WE12CLK WE12CLKb RA12 RB12 QB1b N1 slave_latch kQ=1
x12_2 VDD VSS QA2b WE12CLK WE12CLKb RA12 RB12 QB2b N2 slave_latch kQ=1
x12_3 VDD VSS QA3b WE12CLK WE12CLKb RA12 RB12 QB3b N3 slave_latch kQ=1
x12_4 VDD VSS QA4b WE12CLK WE12CLKb RA12 RB12 QB4b N4 slave_latch kQ=1
x12_5 VDD VSS QA5b WE12CLK WE12CLKb RA12 RB12 QB5b N5 slave_latch kQ=1
x12_6 VDD VSS QA6b WE12CLK WE12CLKb RA12 RB12 QB6b N6 slave_latch kQ=1
x12_7 VDD VSS QA7b WE12CLK WE12CLKb RA12 RB12 QB7b N7 slave_latch kQ=1
x12_8 VDD VSS QA8b WE12CLK WE12CLKb RA12 RB12 QB8b N8 slave_latch kQ=1
x12_9 VDD VSS QA9b WE12CLK WE12CLKb RA12 RB12 QB9b N9 slave_latch kQ=1
x12_10 VDD VSS QA10b WE12CLK WE12CLKb RA12 RB12 QB10b N10 slave_latch kQ=1
x12_11 VDD VSS QA11b WE12CLK WE12CLKb RA12 RB12 QB11b N11 slave_latch kQ=1
x12_12 VDD VSS QA12b WE12CLK WE12CLKb RA12 RB12 QB12b N12 slave_latch kQ=1
x12_13 VDD VSS QA13b WE12CLK WE12CLKb RA12 RB12 QB13b N13 slave_latch kQ=1
x12_14 VDD VSS QA14b WE12CLK WE12CLKb RA12 RB12 QB14b N14 slave_latch kQ=1
x12_15 VDD VSS QA15b WE12CLK WE12CLKb RA12 RB12 QB15b N15 slave_latch kQ=1
x13_0 VDD VSS QA0b WE13CLK WE13CLKb RA13 RB13 QB0b N0 slave_latch kQ=1
x13_1 VDD VSS QA1b WE13CLK WE13CLKb RA13 RB13 QB1b N1 slave_latch kQ=1
x13_2 VDD VSS QA2b WE13CLK WE13CLKb RA13 RB13 QB2b N2 slave_latch kQ=1
x13_3 VDD VSS QA3b WE13CLK WE13CLKb RA13 RB13 QB3b N3 slave_latch kQ=1
x13_4 VDD VSS QA4b WE13CLK WE13CLKb RA13 RB13 QB4b N4 slave_latch kQ=1
x13_5 VDD VSS QA5b WE13CLK WE13CLKb RA13 RB13 QB5b N5 slave_latch kQ=1
x13_6 VDD VSS QA6b WE13CLK WE13CLKb RA13 RB13 QB6b N6 slave_latch kQ=1
x13_7 VDD VSS QA7b WE13CLK WE13CLKb RA13 RB13 QB7b N7 slave_latch kQ=1
x13_8 VDD VSS QA8b WE13CLK WE13CLKb RA13 RB13 QB8b N8 slave_latch kQ=1
x13_9 VDD VSS QA9b WE13CLK WE13CLKb RA13 RB13 QB9b N9 slave_latch kQ=1
x13_10 VDD VSS QA10b WE13CLK WE13CLKb RA13 RB13 QB10b N10 slave_latch kQ=1
x13_11 VDD VSS QA11b WE13CLK WE13CLKb RA13 RB13 QB11b N11 slave_latch kQ=1
x13_12 VDD VSS QA12b WE13CLK WE13CLKb RA13 RB13 QB12b N12 slave_latch kQ=1
x13_13 VDD VSS QA13b WE13CLK WE13CLKb RA13 RB13 QB13b N13 slave_latch kQ=1
x13_14 VDD VSS QA14b WE13CLK WE13CLKb RA13 RB13 QB14b N14 slave_latch kQ=1
x13_15 VDD VSS QA15b WE13CLK WE13CLKb RA13 RB13 QB15b N15 slave_latch kQ=1
x14_0 VDD VSS QA0b WE14CLK WE14CLKb RA14 RB14 QB0b N0 slave_latch kQ=1
x14_1 VDD VSS QA1b WE14CLK WE14CLKb RA14 RB14 QB1b N1 slave_latch kQ=1
x14_2 VDD VSS QA2b WE14CLK WE14CLKb RA14 RB14 QB2b N2 slave_latch kQ=1
x14_3 VDD VSS QA3b WE14CLK WE14CLKb RA14 RB14 QB3b N3 slave_latch kQ=1
x14_4 VDD VSS QA4b WE14CLK WE14CLKb RA14 RB14 QB4b N4 slave_latch kQ=1
x14_5 VDD VSS QA5b WE14CLK WE14CLKb RA14 RB14 QB5b N5 slave_latch kQ=1
x14_6 VDD VSS QA6b WE14CLK WE14CLKb RA14 RB14 QB6b N6 slave_latch kQ=1
x14_7 VDD VSS QA7b WE14CLK WE14CLKb RA14 RB14 QB7b N7 slave_latch kQ=1
x14_8 VDD VSS QA8b WE14CLK WE14CLKb RA14 RB14 QB8b N8 slave_latch kQ=1
x14_9 VDD VSS QA9b WE14CLK WE14CLKb RA14 RB14 QB9b N9 slave_latch kQ=1
x14_10 VDD VSS QA10b WE14CLK WE14CLKb RA14 RB14 QB10b N10 slave_latch kQ=1
x14_11 VDD VSS QA11b WE14CLK WE14CLKb RA14 RB14 QB11b N11 slave_latch kQ=1
x14_12 VDD VSS QA12b WE14CLK WE14CLKb RA14 RB14 QB12b N12 slave_latch kQ=1
x14_13 VDD VSS QA13b WE14CLK WE14CLKb RA14 RB14 QB13b N13 slave_latch kQ=1
x14_14 VDD VSS QA14b WE14CLK WE14CLKb RA14 RB14 QB14b N14 slave_latch kQ=1
x14_15 VDD VSS QA15b WE14CLK WE14CLKb RA14 RB14 QB15b N15 slave_latch kQ=1
x15_0 VDD VSS QA0b WE15CLK WE15CLKb RA15 RB15 QB0b N0 slave_latch kQ=1
x15_1 VDD VSS QA1b WE15CLK WE15CLKb RA15 RB15 QB1b N1 slave_latch kQ=1
x15_2 VDD VSS QA2b WE15CLK WE15CLKb RA15 RB15 QB2b N2 slave_latch kQ=1
x15_3 VDD VSS QA3b WE15CLK WE15CLKb RA15 RB15 QB3b N3 slave_latch kQ=1
x15_4 VDD VSS QA4b WE15CLK WE15CLKb RA15 RB15 QB4b N4 slave_latch kQ=1
x15_5 VDD VSS QA5b WE15CLK WE15CLKb RA15 RB15 QB5b N5 slave_latch kQ=1
x15_6 VDD VSS QA6b WE15CLK WE15CLKb RA15 RB15 QB6b N6 slave_latch kQ=1
x15_7 VDD VSS QA7b WE15CLK WE15CLKb RA15 RB15 QB7b N7 slave_latch kQ=1
x15_8 VDD VSS QA8b WE15CLK WE15CLKb RA15 RB15 QB8b N8 slave_latch kQ=1
x15_9 VDD VSS QA9b WE15CLK WE15CLKb RA15 RB15 QB9b N9 slave_latch kQ=1
x15_10 VDD VSS QA10b WE15CLK WE15CLKb RA15 RB15 QB10b N10 slave_latch kQ=1
x15_11 VDD VSS QA11b WE15CLK WE15CLKb RA15 RB15 QB11b N11 slave_latch kQ=1
x15_12 VDD VSS QA12b WE15CLK WE15CLKb RA15 RB15 QB12b N12 slave_latch kQ=1
x15_13 VDD VSS QA13b WE15CLK WE15CLKb RA15 RB15 QB13b N13 slave_latch kQ=1
x15_14 VDD VSS QA14b WE15CLK WE15CLKb RA15 RB15 QB14b N14 slave_latch kQ=1
x15_15 VDD VSS QA15b WE15CLK WE15CLKb RA15 RB15 QB15b N15 slave_latch kQ=1
x1 VDD VSS N0 WEM WEMb D0 master_latch kN=1
x2 VDD VSS N1 WEM WEMb D1 master_latch kN=1
x3 VDD VSS N2 WEM WEMb D2 master_latch kN=1
x4 VDD VSS N3 WEM WEMb D3 master_latch kN=1
x5 VDD VSS N4 WEM WEMb D4 master_latch kN=1
x6 VDD VSS N5 WEM WEMb D5 master_latch kN=1
x7 VDD VSS N6 WEM WEMb D6 master_latch kN=1
x8 VDD VSS N7 WEM WEMb D7 master_latch kN=1
x9 VDD VSS N8 WEM WEMb D8 master_latch kN=1
x10 VDD VSS N9 WEM WEMb D9 master_latch kN=1
x11 net1 net2 N10 WEM WEMb D10 master_latch kN=1
x12 VDD VSS N11 WEM WEMb D11 master_latch kN=1
x13 VDD VSS N12 WEM WEMb D12 master_latch kN=1
x14 VDD VSS N13 WEM WEMb D13 master_latch kN=1
x15 VDD VSS N14 WEM WEMb D14 master_latch kN=1
x16 VDD VSS N15 WEM WEMb D15 master_latch kN=1
x17 CLK WE15 WE15CLKb VDD VSS WE15CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x18 CLK WE14 WE14CLKb VDD VSS WE14CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x19 CLK WE13 WE13CLKb VDD VSS WE13CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x20 CLK WE12 WE12CLKb VDD VSS WE12CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x21 CLK WE11 WE11CLKb VDD VSS WE11CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x22 CLK WE10 WE10CLKb VDD VSS WE10CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x23 CLK WE9 WE9CLKb VDD VSS WE9CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x24 CLK WE8 WE8CLKb VDD VSS WE8CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x25 CLK WE7 WE7CLKb VDD VSS WE7CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x26 CLK WE6 WE6CLKb VDD VSS WE6CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x27 CLK WE5 WE5CLKb VDD VSS WE5CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x28 CLK WE4 WE4CLKb VDD VSS WE4CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x29 CLK WE3 WE3CLKb VDD VSS WE3CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x30 CLK WE2 WE2CLKb VDD VSS WE2CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x31 CLK WE1 WE1CLKb VDD VSS WE1CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
x32 CLK WE0 WE0CLKb VDD VSS WE0CLK driver_cell kWECLK='kWECLK' kWECLKb='kWECLKb'
XM1 WEMb WEM VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM2 WEMb WEM VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM3 QB0 QB0b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM4 QB0 QB0b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM5 QB1 QB1b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM6 QB1 QB1b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM7 QB2 QB2b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM8 QB2 QB2b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM9 QB3 QB3b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM10 QB3 QB3b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM11 QB4 QB4b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM12 QB4 QB4b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM13 QB5 QB5b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM14 QB5 QB5b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM15 QB6 QB6b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM16 QB6 QB6b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM17 QB7 QB7b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM18 QB7 QB7b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM19 QB8 QB8b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM20 QB8 QB8b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM21 QB9 QB9b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM22 QB9 QB9b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM23 QB10 QB10b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM24 QB10 QB10b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM25 QB11 QB11b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM26 QB11 QB11b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM27 QB12 QB12b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM28 QB12 QB12b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM29 QB13 QB13b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM30 QB13 QB13b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM31 QB14 QB14b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM32 QB14 QB14b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM33 QB15 QB15b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM34 QB15 QB15b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM35 QA0 QA0b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM36 QA0 QA0b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM37 QA1 QA1b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM38 QA1 QA1b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM39 QA2 QA2b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM40 QA2 QA2b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM41 QA3 QA3b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM42 QA3 QA3b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM43 QA4 QA4b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM44 QA4 QA4b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM45 QA5 QA5b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM46 QA5 QA5b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM47 QA6 QA6b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM48 QA6 QA6b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM49 QA7 QA7b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM50 QA7 QA7b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM51 QA8 QA8b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM52 QA8 QA8b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM53 QA9 QA9b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM54 QA9 QA9b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM55 QA10 QA10b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM56 QA10 QA10b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM57 QA11 QA11b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM58 QA11 QA11b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM59 QA12 QA12b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM60 QA12 QA12b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM61 QA13 QA13b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM62 QA13 QA13b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM63 QA14 QA14b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM64 QA14 QA14b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM65 QA15 QA15b VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM66 QA15 QA15b VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
**** begin user architecture code


.param kWECLKb=1
.param kWECLK=1


**** end user architecture code
**.ends

* expanding   symbol:  engn1600-team1/CAD3/slave_latch.sym # of pins=9
** sym_path: CAD3/slave_latch.sym
** sch_path: CAD3/slave_latch.sch
.subckt slave_latch VDD VSS QA WECLK WECLKb RA RB QB D  kQ=1
*.ipin D
*.ipin RA
*.ipin RB
*.ipin WECLKb
*.ipin WECLK
*.opin QA
*.opin QB
*.iopin VDD
*.iopin VSS
XM1 net1 WECLKb net2 VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM2 net1 D VDD VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM3 net3 net2 VDD VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM4 net4 net2 VDD VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM5 VDD WECLK net8 VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM6 net8 net4 net2 VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM7 net1 D VSS VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM8 net1 WECLK net2 VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM9 net3 net2 VSS VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM10 net4 net2 VSS VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM11 net7 net4 net2 VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM12 VSS WECLKb net7 VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM13 net3 net5 QB VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM14 net3 RB QB VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM15 net5 RB VDD VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM16 net5 RB VSS VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM21 net3 net6 QA VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM22 net3 RA QA VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM23 net6 RA VDD VDD pfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM24 net6 RA VSS VSS nfet_03v3 L=0.28u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
.ends


* expanding   symbol:  engn1600-team1/CAD3/master_latch.sym # of pins=6
** sym_path: CAD3/master_latch.sym
** sch_path: CAD3/master_latch.sch
.subckt master_latch VDD VSS Q WEM WEMb D  kN=1
*.ipin D
*.ipin WEMb
*.ipin WEM
*.iopin VSS
*.iopin VDD
*.opin Q
XM3 net1 WEMb net2 VDD pfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM7 net1 D VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM8 Q net2 VDD VDD pfet_03v3 L=0.28u W=0.72u nf=4 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM9 net3 net2 VDD VDD pfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM10 VDD WEM net5 VDD pfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM12 net5 net3 net2 VDD pfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM19 net1 D VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM20 net1 WEM net2 VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM21 Q net2 VSS VSS nfet_03v3 L=0.28u W=0.36u nf=4 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM22 net3 net2 VSS VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM23 net4 net3 net2 VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM24 VSS WEMb net4 VSS nfet_03v3 L=0.28u W=0.36u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
.ends


* expanding   symbol:  engn1600-team1/CAD3/driver_cell.sym # of pins=6
** sym_path: CAD3/driver_cell.sym
** sch_path: CAD3/driver_cell.sch
.subckt driver_cell CLK WE WECLKb VDD VSS WECLK
kWECLK=1
kWECLKb=1

*.ipin CLK
*.ipin WE
*.iopin VSS
*.iopin VDD
*.opin WECLKb
*.opin WECLK
XM13 WECLK net1 VDD VDD pfet_03v3 L=0.28u W='kWECLK*0.72u' nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM14 WECLK net1 VSS VSS nfet_03v3 L=0.28u W='kWECLK*0.36u' nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM1 WECLKb WECLK VDD VDD pfet_03v3 L=0.28u W='kWECLKb*0.72u' nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM2 WECLKb WECLK VSS VSS nfet_03v3 L=0.28u W='kWECLKb*0.36u' nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM3 net1 CLK VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM4 net1 WE VDD VDD pfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM5 net2 WE VSS VSS nfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM6 net1 CLK net2 VSS nfet_03v3 L=0.28u W=0.72u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
**** begin user architecture code


.param kWECLKb=1
.param kWECLK=1


**** end user architecture code
.ends

.end
